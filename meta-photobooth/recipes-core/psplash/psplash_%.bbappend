FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SPLASH_IMAGES_append_photobooth = " file://psplash-photobooth-img.h;outsuffix=raspberrypi"
ALTERNATIVE_PRIORITY_psplash-photobooth[psplash] = "201"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#SPLASH_IMAGES += "file://psplash-photobooth-img.h;outsuffix=photobooth"
#ALTERNATIVE_PRIORITY_psplash-photobooth[psplash] = "11"

